# Keil uVision project STM32F429.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED=1,
  c include: ..\Driver\Board_Driver\STM32F429I-Discovery;..\Driver\Board_Driver\Common;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\Driver\Usart;..\Driver\Delay;..\RT-Thread\bsp;..\RT-Thread\components\finsh;..\RT-Thread\include;..\STemWin522\inc;..\STemWin522\Config;..\STemWin522\Application;..\DspLib\Include;..\STemWin522\APP;..\STemWin522\APP\desk;..\Driver\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\Output\STM32F429.sct
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F429_Periph_Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_fmc.c stm32f4xx_usart.c stm32f4xx_ltdc.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group DRIVER
    ../Driver/Board_Driver/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_ioe.c stm32f429i_discovery_l3gd20.c lcd_rgb.c sdram.c
    ../Driver/Usart/: usart.c
    ../Driver/Delay/: delay.c
    ../Driver/System/: CPUusage.c getThreadInfo.c kernellog.c rtc.c
  group USER
    ../User/: stm32f4xx_it.c main.c
    ../RT-Thread/bsp/: board.c
  group EMWIN_Config
    ../STemWin522/Config/: GUIConf.c GUIDRV_stm32f429i_discovery.c
    ../STemWin522/OS/: GUI_X_OS.c
    ../STemWin522/Lib/: STemWin540_CM4_OS_Keil_ot.lib
  group EMWIN_APP
    ../STemWin522/APP/desk/: background.c iconbitmap.c iconviewdemo.c TestAPP.c sys_startup.c buttonuser.c systemset.c calender.c systemrec.c
  group RTT/Sourece
    ../RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group RTT/Ports
    ../RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DSP_Lib
    ../DspLib/: arm_cortexM4lf_math.lib
